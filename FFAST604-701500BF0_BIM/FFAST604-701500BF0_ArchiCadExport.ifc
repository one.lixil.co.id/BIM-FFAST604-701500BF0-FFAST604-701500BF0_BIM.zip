Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T09:45:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 09:45:50 2023 * Host: L0310_2208R689 * Database: C:\Users\phitssat\AppData\Local\Temp\bb6f013f-03b1-4947-96b7-5025e4dcd981\97058a5b-5fff-4aaf-b44c-3f73d68f29a2\ifc * Database version: 5507 * Database creation date: Thu Mar 30 09:45:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 09:45:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 09:45:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_347134
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAST604-701500BF0_REVIT:Winston Exposed Shower Mono (Lever Handle), FFAST604-701500BF0_REVIT:Winston Exposed Shower Mono (Lever Handle):347134
In: Level 1
Material: Chrome
Pset_DistributionFlowElementCommon - Reference: Winston Exposed Shower Mono (Lever Handle); sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
